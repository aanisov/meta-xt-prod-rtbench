IMAGE_FEATURES += "ssh-server-openssh"

IMAGE_INSTALL = " \
    dhcp-client \
"
