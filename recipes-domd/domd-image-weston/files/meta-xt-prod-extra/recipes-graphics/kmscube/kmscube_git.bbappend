DEPENDS_remove = "libgbm"
DEPENDS_append = " mesa"
